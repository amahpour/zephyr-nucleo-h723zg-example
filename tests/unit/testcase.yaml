## tests/unit/testcase.yaml
```yaml
tests:
  unit.regs:
    tags:
      - unit
      - regs
    platform_allow: qemu_x86
    integration_platforms:
      - qemu_x86
```
